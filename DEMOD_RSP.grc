options:
  parameters:
    author: ve3svf
    generate_options: qt_gui
    id: DEMOD_RSP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ATTEN_1
  id: variable_qtgui_range
  parameters:
    label: LNA Attenuation
    rangeType: int
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: bbgain_slider
  id: variable_qtgui_range
  parameters:
    label: BB Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: bitrate
  id: variable
  parameters:
    value: sf * (1 / (2**sf / float(bw)))
  states: {}
- name: bw
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: capture_freq
  id: variable
  parameters:
    value: 434.0e6
  states: {}
- name: ifgain_slider
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '23'
  states: {}
- name: rfgain_slider
  id: variable_qtgui_range
  parameters:
    label: RF Gain (Inverse Gain)
    start: '0'
    step: '1'
    stop: '100'
    value: '36'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(5e6)
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: float(bw) / (2**sf)
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: int((samp_rate*2)/5)
    type: complex
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: int(bw)
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,True]'
    samp_rate: int(2e6)
    sf: sf
    soft_decoding: 'True'
  states: {}
- name: lora_rx_1
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,True]'
    samp_rate: int(2e6)
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: byte
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '3006'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl_tcp=127.0.0.1:1234"'
    bb_gain0: bbgain_slider
    freq0: 434e6
    gain0: rfgain_slider
    gain_mode0: 'True'
    if_gain0: ifgain_slider
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_throttle_0, '0', lora_rx_0, '0']
- [blocks_throttle_0, '0', lora_rx_1, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [lora_rx_0, '0', network_tcp_sink_0, '0']
- [lora_rx_1, '0', network_tcp_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
