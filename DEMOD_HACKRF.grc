options:
  parameters:
    author: ve3svf
    generate_options: qt_gui
    id: DEMOD_HACKRF
    output_language: python
    title: Demodulator Spectrum View
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: sf * (1 / (2**sf / float(bw)))
  states: {}
- name: bw
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: capture_freq
  id: variable
  parameters:
    value: 434.0e6
  states: {}
- name: ifgain_slider
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    start: '0'
    step: '1'
    stop: '40'
    value: '36'
  states: {}
- name: receive_offset
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(5e6)
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: float(bw) / (2**sf)
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: vga_slider
  id: variable_qtgui_range
  parameters:
    label: VGA Gain
    start: '0'
    step: '1'
    stop: '62'
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-receive_offset'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 2e6
    type: complex
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: int(bw)
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,True]'
    samp_rate: int(2e6)
    sf: sf
    soft_decoding: 'True'
  states: {}
- name: lora_rx_1
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,True]'
    samp_rate: int(2e6)
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: byte
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '3006'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2e6
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '2'
    type: ccc
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    center_freq: target_freq-receive_offset
    gain: ifgain_slider
    samp_rate: samp_rate
    type: fc32
    vga: vga_slider
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0, '0', lora_rx_0, '0']
- [blocks_throttle_0, '0', lora_rx_1, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [lora_rx_0, '0', network_tcp_sink_0, '0']
- [lora_rx_1, '0', network_tcp_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']
- [soapy_hackrf_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
