options:
  parameters:
    author: ve3svf
    generate_options: qt_gui
    id: DEMOD_PLUTO
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: sf * (1 / (2**sf / float(bw)))
  states: {}
- name: bw
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: capture_freq
  id: variable
  parameters:
    value: 434.0e6
  states: {}
- name: rfgain_slider
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '72'
    value: '36'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(3e6)
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: float(bw) / (2**sf)
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 434e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: int((samp_rate*2)/3)
    type: complex
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(target_freq)
    gain1: '''manual'''
    len_tag_key: ''
    manual_gain1: '36'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: int(bw)
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,True]'
    samp_rate: int(2e6)
    sf: sf
    soft_decoding: 'True'
  states: {}
- name: lora_rx_1
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,True]'
    samp_rate: int(2e6)
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: byte
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '3006'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 2e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '3'
    interp: '2'
    type: ccc
  states: {}

connections:
- [blocks_throttle_0, '0', lora_rx_0, '0']
- [blocks_throttle_0, '0', lora_rx_1, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [lora_rx_0, '0', network_tcp_sink_0, '0']
- [lora_rx_1, '0', network_tcp_sink_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
